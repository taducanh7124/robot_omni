# IAR project ENCODER_1_KENH_1.ewp, settings and files
configuration ENCODER_1_KENH_1 (ARM, debug)
  General.OGChipSelectEditMenu: STM32F411CE ST STM32F411CE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F411xE
  ICCARM.CCIncludePath2: ../Core/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F4xx/Include; ../Drivers/CMSIS/Include; ..\Core\Cpp\MainCpp\Inc; ..\Core\Cpp\FunctionCpp\Inc; ..\Core\Cpp\LibraryCpp\Inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  OBJCOPY.OOCOutputFile: ENCODER_1_KENH_1.hex
  ILINK.IlinkOutputFile: ENCODER_1_KENH_1.out
  ILINK.IlinkIcfFile: stm32f411xe_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f411xe.s
  group Application/User/Core
    ../Core/Src/: dma.c gpio.c i2c.c main.c stm32f4xx_hal_msp.c stm32f4xx_it.c tim.c usart.c
  group Application/User/Core/Cpp/FunctionCpp/Inc
    ../Core/Cpp/FunctionCpp/Inc/: const.hpp data.hpp input_output.hpp MotorControl.hpp PinConfig.hpp UART_DMA.hpp
  group Application/User/Core/Cpp/FunctionCpp/Src
    ../Core/Cpp/FunctionCpp/Src/: const.cpp data.cpp input_output.cpp MotorControl.cpp UART_DMA.cpp
  group Application/User/Core/Cpp/LibraryCpp/Inc
    ../Core/Cpp/LibraryCpp/Inc/: ArduinoWrapper.h helper_3dmath.h i2c.h I2Cdev.h MPU6050.h MPU6050_6Axis_MotionApps_V6_12.h
  group Application/User/Core/Cpp/LibraryCpp/Src
    ../Core/Cpp/LibraryCpp/Src/: ArduinoWrapper.cpp I2Cdev.cpp MPU6050.cpp
  group Application/User/Core/Cpp/MainCpp/Inc
    ../Core/Cpp/MainCpp/Inc/: led_main.hpp main_cpp.hpp
  group Application/User/Core/Cpp/MainCpp/Src
    ../Core/Cpp/MainCpp/Src/: led_main.cpp main_cpp.cpp
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_exti.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
